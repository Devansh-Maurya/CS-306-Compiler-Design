MOV R1, #0FFH
MOV R2, #0FFH
MOV R3, #0FFH
MOV R4, #0FFH

MOV A,R3
MOV B,R4
MUL AB
MOV 50H,A
MOV 51H,B

MOV A,R3
MOV B, R2
MUL AB
MOV 52H,B
ADDC A,51H
MOV 51H,A

MOV A,R1
MOV B,R4
MUL AB
ADDC A,51H
MOV 51H,A
MOV A,B
ADDC A,52H
MOV 52H,A

MOV A,R1
MOV B,R2
MUL AB
ADDC A,52H
MOV 52H,A
MOV A,B
ADDC A,#00H
MOV 53H,A
END